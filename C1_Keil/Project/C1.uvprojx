# Keil uVision project C1.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: C1 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: -mfpu=fpv4-sp-d16 -mfloat-abi=hard -std=gnu11 -Wno-invalid-utf8 -Wno-unsafe-buffer-usage
  c include: ..\Core\Inc;..\Drivers\STM32F4xx_HAL_Driver\inc;..\Drivers\CMSIS;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\GCC\ARM_CM4F;..\Middlewares\FreeRTOS
  asm define: USE_HAL_DRIVER,STM32F407xx
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c protocol.c motor.c encoder.c app_tasks.c
  group CMSIS
    ../Drivers/CMSIS/: system_stm32f4xx.c startup_stm32f407xx.s
  group STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_exti.c
  group FreeRTOS
    ../Middlewares/FreeRTOS/: tasks.c queue.c list.c timers.c FreeRTOSConfig.h
    ../Middlewares/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 4.3.0
